<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\Desktop\EiE\eie_software\razor_sam3u2-master\firmware_ascii\iar_8_10_1\eie_ascii-01.ewp</path>
    </project>
    <batchBuild />
</workspace>
